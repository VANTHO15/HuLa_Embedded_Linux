IMAGE_INSTALL = "${PAYLOAD}"
LICENSE = "MIT"
inherit image
inherit image-container