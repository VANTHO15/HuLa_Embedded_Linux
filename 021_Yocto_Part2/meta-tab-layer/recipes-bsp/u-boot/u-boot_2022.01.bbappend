FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://gpio-hog.cfg"